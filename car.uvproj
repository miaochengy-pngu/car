# Keil uVision project car.uvproj, settings and files
target STC89C52RC Car (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: car +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  asm include: .\inc
  group Application
    ./: main.c
  group Drivers
    ./src/: motor.c tracking.c delay.c
  group Headers
    ./inc/: config.h motor.h tracking.h delay.h
