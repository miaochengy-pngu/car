# Keil uVision project car.uvproj, settings and files
target STC89C52RC Car (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: car +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\System;..\Hardware\Motor;..\Hardware\Tracking;..\Hardware\PWM;..\Control
  asm include: as above
  group USER
    ../User/: main.c
  group CONTROL
    ../Control/: line_control.c line_control.h
  group HARDWARE
    ../Hardware/Motor/: motor.c motor.h
    ../Hardware/Tracking/: tracking.c tracking.h
    ../Hardware/PWM/: pwm.c pwm.h
  group SYSTEM
    ../System/: config.h delay.c delay.h
